# Keil uVision project del_ther.uvprojx, settings and files
target STM32F103C8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: del_ther
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c Thread.c hj.c Thread2.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
